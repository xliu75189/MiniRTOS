# Keil uVision project MiniRTOS.uvprojx, settings and files
target dbg (6230000::V6.23::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MiniRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\CMSIS\Include;..\ek-tm4c123gxl;..\MiniRtos\src;;..\MiniRtos\port;..\bsp
  asm define: Stack_Size=1024 Heap_Size=128
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: MiniRTOS.sct
  link misc: --entry Reset_Handler
  group Applicatioin
    ../Application/: main.c
  group ek-tm4c123gxl
    ../ek-tm4c123gxl/: system_TM4C123GH6PM.c system_TM4C123GH6PM.h TM4C123GH6PM.h
    ../ek-tm4c123gxl/arm/: startup_TM4C123GH6PM.s
  group bsp
    ../bsp/: bsp.c bsp.h
  group MiniRtos
    ../MiniRtos/src/: os_task.c os.h os_sem.c os_msg_q.c os_utils_event.c os_utils_event.h os_utils_list.c os_utils_list.h qassert.h os_sched.c os_sched.h
    ../MiniRtos/port/: os_cpu.h os_cpu_a.asm
